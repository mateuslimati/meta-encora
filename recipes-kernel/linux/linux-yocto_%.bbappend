FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE:arm64-encora = "arm64-encora"

KBRANCH:arm64-encora = "v5.15/standard/base"
KMACHINE:arm64-encora  = "qemuarm64"